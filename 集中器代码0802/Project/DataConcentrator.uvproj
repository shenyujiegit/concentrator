# Keil uVision project DataConcentrator.uvproj, settings and files
target DataConcentrator (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DataConcentrator +hex
  c flags: Optim=1
  c define: STM32F40XX,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER\Device;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM4F;..\FWLIB\inc;..\USER\platform;..\USER\Aplication;..\PROTOCOL;..\SYSTEM\delay;..\SYSTEM\sys;..\USER\Device;..\ETHERNET;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip-1.4.1\port\STM32F4x7;..\LWIP\lwip-1.4.1\port\STM32F4x7\FreeRTOS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/Aplication/: main.c rtos_task.c common.c stm32f4xx_it.c task_led.c
  group DEVICE
    ../USER/Device/: dp83848.c key.c led.c relay.c plc.c zigbee.c rs485.c ec20.c rx8010s.c eeprom.c
  group PLATFORM
    ../USER/platform/: stm32_config.h usart.c watch_dog.c iic.c spi.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4x7_eth.c
  group FREERTOS
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FREERTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FREERTOS/portable/MemMang/: heap_4.c
  group ETHERNET
    ../ETHERNET/: netconf.c task_lwip_init.c task_tcp_client.c lwip_comm.c fs.c httpd.c httpd_cgi_ssi.c
  group LWIP
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c lwip_timers.c udp.c
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c
    ../LWIP/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
